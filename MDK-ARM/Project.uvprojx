# Keil uVision project Project.uvprojx, settings and files
target STM32F103RB-Nucleo (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103RB-Nucleo
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F103xB,USE_FULL_LL_DRIVER
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../../../../../../Drivers/STM32F1xx_HAL_Driver/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Example/MDK-ARM
    ./: startup_stm32f103xb.s
  group Drivers/STM32F1xx_LL_Driver
    ../../../../../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_ll_rcc.c stm32f1xx_ll_utils.c
    ../Inc/: stm32f1xx_ll_usart.h
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Example/User
    ../Src/: main.c stm32f1xx_it.c stm32f1xx_ll_usart.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 4.3.0
